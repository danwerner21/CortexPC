.
.
.         NULL Printer Driver for MDEX
.
          idt       "PRNT-SIO"
          copy      "../systemdef/sysdef"
          dstk      r10
.
.         Printer control table
.
          dorg      0
.
prdvad    bss       2                   printer device address
prcrdly   bss       2                   carriage return delay time
prautolf  bss       2                   cr does lf if nonzero
prvpos    bss       2                   vertical position in page body
prffdly   bss       2                   form feed delay time
prbody    bss       2                   page body length
prtop     bss       2                   lines at top of page
prminl    bss       2                   minimum line length
prhpos    bss       2                   horizontal carriage position
prlfdly   bss       2                   line feed delay
prffsim   bss       2                   simulate form feed if nonzero
prbot     bss       2                   lines in bottom margin
.
          rorg
.
.
.         Enter here to send data to printer
.
.         LI        R1,<function>
.         LI        R5,<buffer address>
.         LI        R6,<buffer length>
.         LI        R8,<control table address>
.         BL        PIOPRTS
.         <return>                      R1 = status
.
.         Status:  0 = normal completion
.                  1 = I/O error
.                  2 = timeout
.
pioprts*  li	   r0,0
	  rt
.
.         Control tables for printers
.
ut$pr1*   data      0                   device address
          data      0                   delay after carriage return
          data      0                   cr does lf flag
          data      0                   vertical position
          data      0                   delay after form feed
          data      60                  lines in page body
          data      4                   lines in top margin
          data      0                   minimum line length
          data      0                   horizontal position
          data      0                   line feed delay count
          data      0                   simulate form feed in software
          data      0                   bottom margin length
.
          end       .
